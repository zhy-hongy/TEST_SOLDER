# Keil uVision project SolderMid.uvprojx, settings and files
target THT_L075 (6230000::V6.23::ARMCLANG)
  device: N32G435CB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SolderMid_THT_L075 +hex
  AfterMake: fromelf --bin -o .\bin\SolderMid_THT_L075.bin .\Objects\SolderMid_THT_L075.axf
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=2 v6Lang=3 v6LangP=5 wLevel=3
  c define: N32G43X, USE_STDPERIPH_DRIVER, THT_L075,LED_SCREEN,
  c include: .\Libraries\CMSIS\core;.\Libraries\CMSIS\device\startup;.\Libraries\CMSIS\device;.\Libraries\n32g43x_std_periph_driver\inc;.\Sources\Alg\inc;.\Sources\Bsp\inc;.\Sources\Encryption\inc;.\Sources\Srcs\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ./Libraries/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ./Libraries/CMSIS/device/: system_n32g43x.c
  group LIBS
    ./Libraries/n32g43x_std_periph_driver/src/: misc.c n32g43x_adc.c n32g43x_can.c n32g43x_comp.c n32g43x_crc.c n32g43x_dac.c n32g43x_dbg.c n32g43x_dma.c n32g43x_exti.c n32g43x_flash.c n32g43x_gpio.c n32g43x_i2c.c n32g43x_iwdg.c n32g43x_lptim.c n32g43x_lpuart.c n32g43x_opamp.c n32g43x_pwr.c n32g43x_rcc.c n32g43x_rtc.c n32g43x_spi.c n32g43x_tim.c n32g43x_usart.c n32g43x_wwdg.c
  group BSP
    ./Sources/Bsp/src/: bsp_all.c adc_aq.c beep.c bsp_time.c heat_ctrl.c key.c led.c mux_ctrl.c rcc.c systick.c zero_check.c uart_usb.c tool_io.c led_screen.c lcd_lcd_version.c i2c.c
  group USER
    ./Sources/Srcs/src/: n32g43x_it.c solder_adc.c main.cpp solder.c solder_key_display.c
    ./Sources/Srcs/src/module/: solder_error.c solder_heat.c solder_param.c solder_power.c solder_stage.c solder_temp.c solder_tool.c
  group MIDTIER
    ./Sources/Srcs/src/: counter_ms_us.c queue.c tempearture_cal.c tool_det.c controller.c power_supply.c dedbg.c
  group ALGORITHM
    ./Sources/Alg/src/: kalman_2d_opt.c slope_slide_window.c
  group ENCRYPTION
    ./Sources/Encryption/src/: aes.c app_xxtea.c des.c encrypt_func.c sha256.c sm3.c sm4.c
target THT_M120 (6230000::V6.23::ARMCLANG)
  device: N32G435CB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.6
  cpu: as above
  output: SolderMid_THT_M120 +hex
  AfterMake: fromelf --bin -o .\bin\SolderMid_THT_M120.bin .\Objects\SolderMid_THT_M120.axf
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=2 v6Lang=3 v6LangP=5 wLevel=3
  c define: N32G43X, USE_STDPERIPH_DRIVER, THT_M120,LED_SCREEN,
  c include: .\Libraries\CMSIS\core;.\Libraries\CMSIS\device\startup;.\Libraries\CMSIS\device;.\Libraries\n32g43x_std_periph_driver\inc;.\Sources\Alg\inc;.\Sources\Bsp\inc;.\Sources\Encryption\inc;.\Sources\Srcs\inc;.\Sources\Srcs\src\module
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
